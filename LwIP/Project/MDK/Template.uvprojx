# Keil uVision project Template.uvprojx, settings and files
target Template (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL
  c include: ..\Include;..\..\Library\STM32F10x_StdPeriph_Driver\inc;..\..\Library\STM32_ETH_Driver\inc;..\..\Utilities\lwip-1.3.1\port;..\..\Utilities\lwip-1.3.1\src\include;..\..\Utilities\lwip-1.3.1\src\include\ipv4;..\..\Utilities\lwip-1.3.1\src\include\lwip;..\..\Utilities\lwip-1.3.1\src\include\netif;..\..\Utilities\STM32_EVAL;..\..\Utilities\STM32_EVAL\STM3210C_EVAL;..\..\Library\CMSIS\Core\CM3
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USERS
    ../Source/: main.c stm32f10x_it.c stm32f107.c netconfig.c
  group CORE
    ../../Library/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c core_cm3.h system_stm32f10x.h stm32f10x.h
    ../../Library/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_cl.s
  group STM32LIB
    ../../Library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group LwIP_core
    ../../Utilities/lwip-1.3.1/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../../Utilities/lwip-1.3.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LwIP_api
    ../../Utilities/lwip-1.3.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP_netif
    ../../Utilities/lwip-1.3.1/src/netif/: etharp.c ethernetif.c loopif.c slipif.c
  group ETH_Driver
    ../../Library/STM32_ETH_Driver/src/: stm32_eth.c
