# Keil uVision project Template.uvprojx, settings and files
target Template (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Include;..\..\Library\STM32F10x_StdPeriph_Driver\inc;..\..\Library\STM32_ETH_Driver\inc;..\..\Library\CMSIS\Core\CM3;..\..\Utilities\FreeRTOS\include;..\..\Utilities\lwip-2.1.0\ports\include;..\..\Utilities\lwip-2.1.0\src\include;..\..\Utilities\lwip-2.1.0\src\include\compat;..\..\Utilities\lwip-2.1.0\src\include\lwip;..\..\Utilities\lwip-2.1.0\src\include\netif;..\..\Utilities\lwip-2.1.0\src\netif;..\..\Utilities\LinkSDK\core;..\..\Utilities\LinkSDK\core\utils;..\..\Utilities\LinkSDK\core\sysdep
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USERS
    ../Source/: main.c stm32f10x_it.c stm32f107.c netconfig.c tcp_client.c mqtt_client.c aiotport.c
  group CORE
    ../../Library/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c core_cm3.h system_stm32f10x.h stm32f10x.h
    ../../Library/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_hd.s
  group STM32LIB
    ../../Library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group LwIP_core
    ../../Utilities/lwip-2.1.0/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../Utilities/lwip-2.1.0/src/core/ipv4/: ip4_frag.c ip4_addr.c ip4.c igmp.c icmp.c etharp.c dhcp.c autoip.c
  group LwIP_api
    ../../Utilities/lwip-2.1.0/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP_netif
    ../../Utilities/lwip-2.1.0/src/netif/: ethernet.c
    ../../Utilities/lwip-2.1.0/ports/: ethernetif.c
  group LwIP_sys
    ../../Utilities/lwip-2.1.0/ports/: sys_arch.c
  group LwIP_config
    ../../Utilities/lwip-2.1.0/src/include/lwip/: opt.h
    ../../Utilities/lwip-2.1.0/ports/include/: lwipopts.h
  group ETH_Driver
    ../../Library/STM32_ETH_Driver/src/: stm32_eth.c
  group FreeRTOS
    ../../Utilities/FreeRTOS/: croutine.c event_groups.c heap_4.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/include
    ../../Utilities/FreeRTOS/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h portmacro.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group CLINK/core
    ../../Utilities/LinkSDK/core/: aiot_mqtt_api.c aiot_state_api.c
    ../../Utilities/LinkSDK/core/utils/: core_auth.c core_diag.c core_global.c core_http.c core_log.c core_sha256.c core_string.c
    ../../Utilities/LinkSDK/core/sysdep/: core_adapter.c core_sysdep.c
